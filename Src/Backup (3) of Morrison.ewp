# IAR project Backup (3) of Morrison.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$TIVAWARE$; -I$BIOS$/ti/sysbios/posix; -DPART_TM4C1294NCPDT; -Dewarm; -DTIVAWARE; --debug; --silent; -I$NDK$/ti/ndk/inc/bsd; -DNET_NDK; -DWOLFSSL_TIRTOS
  ICCARM.CCIncludePath2: BoardManagment; Morrison; Morrison\BLE; Morrison\Communication; Morrison\Configuration; Morrison\Drivers; Morrison\EventManager; Morrison\NFC; Morrison\Peripherals; Morrison\Status; Morrison\System; Morrison\Driverlib; Morrison\Wireless; wolfssl-3.9.10; C:\ti\tirtos_tivac_2_16_01_14\products\tidrivers_tivac_2_16_01_13\packages\ti\drivers; C:\ti\tirtos_tivac_2_16_01_14\products\tidrivers_tivac_2_16_01_13\packages\ti\drivers\wifi; C:\ti\tirtos_tivac_2_16_01_14\products\tidrivers_tivac_2_16_01_13\packages\ti\mw\wifi\cc3x00\simplelink\include; C:\ti\tirtos_tivac_2_16_01_14\products\tidrivers_tivac_2_16_01_13\packages\ti\mw\wifi\cc3x00\simplelink\source; C:\ti\tirtos_tivac_2_16_01_14\products\tidrivers_tivac_2_16_01_13\packages\ti\mw\wifi\cc3x00\simplelink; C:\ti\tirtos_tivac_2_16_01_14\products\tidrivers_tivac_2_16_01_13\packages\ti\mw\wifi\cc3x00\oslib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Morrison.srec
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: Morrison.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_EK_TM4C1294XL.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $TIVAWARE$/grlib/ewarm/Exe/grlib.a; $TIVAWARE$/usblib/ewarm/Exe/usblib.a; $TIVAWARE$/driverlib/ewarm/Exe/driverlib.a; --silent; --cpu=Cortex-M4F; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkAdditionalLibs: Morrison\Wireless\script_uploader_lib.a; wolfssl-3.9.10\tirtos\packages\ti\net\wolfssl\lib\wolfssl.arm4f
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$TIVAWARE$; -I$BIOS$/ti/sysbios/posix; -DPART_TM4C1294NCPDT; -Dewarm; -DTIVAWARE; --debug; --silent
  ICCARM.CCOptLevel: 3
  group BoardManagment
    BoardManagment/: Board.h EK_TM4C1294XL.c
  group Configuration/Configuration files
    ./: Morrison.cfg Morrison_EK_TM4C1294XL.icf
  group Configuration/Documentation
    ../Doc/: How to Build IAR TI-RTOS.txt
  group Driverlib
    Driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c rtos_bindings.h shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c sysexc.h systick.c timer.c uart.c udma.c usb.c watchdog.c
    driverlib/: adc.h aes.h can.h comp.h cpu.h crc.h debug.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h onewire.h pin_map.h pwm.h qei.h rom.h rom_map.h shamd5.h ssi.h sw_crc.h sysctl.h systick.h timer.h uart.h udma.h usb.h watchdog.h
  group Morrison/Communication
    Morrison/Communication/: HTTPClient.c WebServer.c
  group Morrison/Drivers
    Morrison/Drivers/: GPIOs.c SPITivaDMA.c TM4CADC.c TM4CDMA.c TM4CEEPROM.c TM4CFlash.c TM4CI2C.c TM4CI2CTiva.c TM4CPWM.c TM4CRTC.c TM4CSPI.c TM4CTIMER.c TM4CUART.c TM4CWiFi.c USBCDCD.c WiFiCC3100.c
  group Morrison/EventManager
    Morrison/EventManager/: ErrorLog.c EventLog.c
  group Morrison/Peripherals
    Morrison/Peripherals/: Button.c Dataflash.c LEDs.c
  group Morrison/System
    Morrison/System/: Initialization.c Main.c SelfTest.c
  group Morrison/Wireless
    Morrison/Wirelss/: script_uploader.h syn_types.h
  group Simplink
    $TIDRIVERS$/ti/mw/wifi/cc3x00/simplelink/: cc3x00_control.h cc3x00_spi.h user.h
  group Simplink/include
    $TIDRIVERS$/ti/mw/wifi/cc3x00/simplelink/include/: device.h fs.h netapp.h netcfg.h simplelink.h socket.h trace.h wlan.h wlan_rx_filters.h
  group Simplink/source
    $TIDRIVERS$/ti/mw/wifi/cc3x00/simplelink/source/: device.c driver.c driver.h flowcont.c flowcont.h fs.c netapp.c netcfg.c objInclusion.h protocol.h socket.c spawn.c spawn.h wlan.c
  group WifiApp/source
    $EXAMPLE_ROOT$/EK_TM4C1294XL/tcpEchoCC3X00/: EK_TM4C1294XL.c sockets.c tcpEchoCC3X00.c
    $TIDRIVERS$/ti/drivers/: WiFi.c
    $TIDRIVERS$/ti/drivers/wifi/: WiFiCC3100.c
  group WifiApp/include
    $EXAMPLE_ROOT$/EK_TM4C1294XL/tcpEchoCC3X00/: Board.h EK_TM4C1294XL.h sockets.h
    $TIDRIVERS$/ti/drivers/: WiFi.h
    $TIDRIVERS$/ti/drivers/wifi/: WiFiCC3100.h
  group WiFiRtosPort/include
    $TIDRIVERS$/ti/mw/wifi/cc3x00/oslib/: osi.h
  group WiFiRtosPort/source
    $TIDRIVERS$/ti/drivers/wifi/: osi_tirtos.c
