# IAR project Backup of Morrison.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$TIVAWARE$; -I$BIOS$/ti/sysbios/posix; -DPART_TM4C1294NCPDT; -Dewarm; -DTIVAWARE; --debug; --silent; -I$NDK$/ti/ndk/inc/bsd; -DNET_NDK; -DWOLFSSL_TIRTOS
  ICCARM.CCIncludePath2: BoardManagment; Morrison; Morrison\BLE; Morrison\Communication; Morrison\Configuration; Morrison\Drivers; Morrison\EventManager; Morrison\NFC; Morrison\Peripherals; Morrison\Status; Morrison\System; Morrison\Driverlib; Morrison\Wireless; wolfssl-3.9.10
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Morrison.srec
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: Morrison.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_EK_TM4C1294XL.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $TIVAWARE$/grlib/ewarm/Exe/grlib.a; $TIVAWARE$/usblib/ewarm/Exe/usblib.a; $TIVAWARE$/driverlib/ewarm/Exe/driverlib.a; --silent; --cpu=Cortex-M4F; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkAdditionalLibs: Morrison\Wireless\script_uploader_lib.a; wolfssl-3.9.10\tirtos\packages\ti\net\wolfssl\lib\wolfssl.arm4f
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$TIVAWARE$; -I$BIOS$/ti/sysbios/posix; -DPART_TM4C1294NCPDT; -Dewarm; -DTIVAWARE; --debug; --silent
  ICCARM.CCOptLevel: 3
  group BoardManagment
    BoardManagment/: Board.h EK_TM4C1294XL.c
  group Configuration/Configuration files
    ./: Morrison.cfg Morrison_EK_TM4C1294XL.icf
  group Configuration/Documentation
    ../Doc/: How to Build IAR TI-RTOS.txt
  group Driverlib
    Driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h onewire.c onewire.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group Morrison/Communication
    Morrison/Communication/: HTTPClient.c WebServer.c
  group Morrison/Drivers
    Morrison/Drivers/: GPIOs.c SPITivaDMA.c TM4CADC.c TM4CDMA.c TM4CEEPROM.c TM4CFlash.c TM4CI2C.c TM4CI2CTiva.c TM4CPWM.c TM4CRTC.c TM4CSPI.c TM4CTIMER.c TM4CUART.c TM4CWiFi.c USBCDCD.c WiFiCC3100.c
  group Morrison/EventManager
    Morrison/EventManager/: ErrorLog.c EventLog.c
  group Morrison/Peripherals
    Morrison/Peripherals/: Button.c Dataflash.c LEDs.c
  group Morrison/System
    Morrison/System/: Initialization.c Main.c SelfTest.c
  group Morrison/Wireless
    Morrison/Wirelss/: script_uploader.h syn_types.h
